# Keil uVision project 0721.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 0721 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F1xx_HAL_Driver\Inc;..\User;..\APP;..\Middlewares\FreeRTOS\Source\include;..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group STM32F1__HAL
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_iwdg.c
  group USER
    ../User/: main.c stm32f1xx_it.c can.c adc.c gpio_output.c rs485.c usart.c watchdog.c
  group APP
    ../APP/: app_acquisition.c app_can.c app_freertos.c app_modbus.c
  group FreeRTOS
    ../Middlewares/FreeRTOS/Source/: tasks.c list.c queue.c
    ../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group DOC
    ../Doc/: README.txt
